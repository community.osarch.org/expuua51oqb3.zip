Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView]
File name: 2321-test_4x0.ifc
Time: 2024-09-09T15:35:58+02:00
Written by: IfcOpenShell 0.8.0
Made in: Bonsai 0.8.0

# IfcProject, My Project
Classification: NL-SfB tabel 1 Classification; Document: Begane Grond; Palenplan; Renvooi PP PBP; Palenplan; svg test

# IfcAnnotation: 1,8 (9)
Type - ApplicableOccurrence: IfcAnnotation/TEXT
Type - EPset_Annotation - Classes: small
Group: Renvooi PP PBP
Name
2 x 1,8
1,8 | EPset_Annotation - Classes: bold small
1,8.001
1,8.003
1,8.004
1,8.002
1,8.001 | EPset_Annotation - Classes: italic small
1,8 | EPset_Annotation - Classes: italic small

# IfcAnnotation: 2,5 (3)
Type - ApplicableOccurrence: IfcAnnotation/TEXT
Group: Renvooi PP PBP
Name | Classes
2,5 | bold small
2,5 | bold regular
2,5.001 | small

# IfcAnnotation: 3,5
Type - ApplicableOccurrence: IfcAnnotation/TEXT
Type - EPset_Annotation - Classes: large
EPset_Annotation - Classes: bold large
Group: Renvooi PP PBP

# IfcAnnotation: DIMENSION (3)
Name | Group
DIMENSION | Begane Grond
DIMENSION | Palenplan
DIMENSION | Renvooi PP PBP

# IfcAnnotation: DRAWING (3)
EPset_Drawing - TargetView: PLAN_VIEW; Scale: 1/100; HumanScale: 1:100; HasUnderlay: no; HasLinework: yes; HasAnnotation: yes; GlobalReferencing: yes; Stylesheet: drawings/assets/INB_BWK_stylesheet_1_100_2.css; Markers: drawings/assets/INB_BWK_markers_2.svg; Symbols: drawings/assets/INB_BWK_symbols_2.svg; Patterns: drawings/assets/INB_BWK_patterns.svg; ShadingStyles: drawings/assets/shading_styles.json; CurrentShadingStyle: Blender Default
Name | Document | Group
Begane Grond | X drawings/Begane Grond.svg | Begane Grond
Palenplan | X drawings/Palenplan.svg | Palenplan | EPset_Drawing - Include: IfcTypeProduct, IfcProduct, location="Fundering"
Renvooi PP PBP | X drawings/Renvooi PP PBP.svg | Renvooi PP PBP

# IfcAnnotation: LINEWORK (2)
Group: Renvooi PP PBP
Name
LINEWORK | EPset_Annotation - Classes: dashed
LINEWORK

# IfcAnnotation: blank, FILL_AREA
EPset_Annotation - Classes: white
Group: Renvooi PP PBP

# IfcAnnotation: num (27)
Type - ApplicableOccurrence: IfcAnnotation/TEXT
Group: Palenplan
Name
22 x num
num.018
4 x num | EPset_Annotation - Classes: italic bold large

# IfcAnnotation: pn_1_8
Type - ApplicableOccurrence: IfcAnnotation/TEXT
Type - EPset_Annotation - Symbol: pn_1_8; Classes: small bold
Group: Palenplan

# IfcAnnotation: son_kl_uit (4)
Type - ApplicableOccurrence: IfcAnnotation/SYMBOL
Type - EPset_Annotation - Symbol: son_kl_uit
Group: Palenplan
Name
3 x son_kl_uit
son_kl_uit.001

# IfcBeam, NLRS_28_SR_balk_beton BB 400x600.003
In: Fundering
PredefinedType: BEAM; Group: Fundering/Palenplan; Palenplan totaal, types & inhoud
Qto_BeamBaseQuantities - GrossSurfaceArea: 9.19357 m2; GrossVolume: 1.04693 m3; Length: 3100 mm; NetSurfaceArea: 9.19357 m2; NetVolume: 1.04693 m3; OuterSurfaceArea: 5.70379 m2

# IfcBeam: BB 400x600 (6)
In: Fundering
Type - PredefinedType: BEAM; Classification: 16.1 funderingsconstructies; voeten en balken (NL-SfB tabel 1 Classification); Material: gewapendbetonprefab
Type - Pset_BeamCommon - IsExternal: yes; LoadBearing: yes; Status: EXISTING
EPset_Parametric - Engine: Bonsai.DumbProfile
Group: Fundering/Palenplan; Palenplan totaal, types & inhoud
Name | GrossSurfaceArea (m2) = NetSurfaceArea (m2) | GrossVolume (m3) = NetVolume (m3) | Length (mm) | OuterSurfaceArea (m2)
2 x NLRS_28_SR_balk_beton BB 400x600 | 16.41 | 1.9116 | 7965 | 15.93
NLRS_28_SR_balk_beton BB 400x600 | 13.83 | 1.602 | 6675 | 13.35
NLRS_28_SR_balk_beton BB 400x600 | 8.08 | 0.912 | 3800 | 7.6
NLRS_28_SR_balk_beton BB 400x600.002 | 27.06 | 3.1896 | 13290 | 26.58
NLRS_28_SR_balk_beton BB 400x600 | 24.48 | 2.88 | 12000 | 24

# IfcBeam: KPV200 (6)
In: Begane Grond
Type - PredefinedType: HOLLOWCORE; Material: gewapendbetonprefab
Type - Pset_BeamCommon - LoadBearing: yes; Status: NEW
EPset_Parametric - Engine: Bonsai.DumbProfile

# IfcBeam: NLRS_28_SR_balk_beton BB 350x600 (6)
In: Fundering
Type - PredefinedType: BEAM; Classification: 16.1 funderingsconstructies; voeten en balken (NL-SfB tabel 1 Classification); Material: gewapendbetonprefab
Type - Pset_BeamCommon - IsExternal: yes; LoadBearing: yes; Status: NEW
EPset_Parametric - Engine: Bonsai.DumbProfile
Group: Fundering/Palenplan; Palenplan totaal, types & inhoud
Name | GrossSurfaceArea (m2) = NetSurfaceArea (m2) | GrossVolume (m3) = NetVolume (m3) | Length (mm) | OuterSurfaceArea (m2)
NLRS_28_SR_balk_beton BB 350x600.004 | 31.143 | 3.3957 | 16170 | 30.723
NLRS_28_SR_balk_beton BB 350x600 | 13.1025 | 1.40175 | 6675 | 12.6825
2 x NLRS_28_SR_balk_beton BB 350x600 | 36.558 | 3.9942 | 19020 | 36.138
NLRS_28_SR_balk_beton BB 350x600 | 32.416 | 3.5364 | 16840 | 31.996
NLRS_28_SR_balk_beton BB 350x600 | 9.6255 | 1.01745 | 4845 | 9.2055

# IfcGroup (3)
Name | Description
Fundering/Palenplan | {"type": "BBIM_Search", "query": "IfcTypeProduct, IfcProduct, location=\"Fundering\""}
Palenplan totaal, types & inhoud | {"type": "BBIM_Search", "query": "IfcBuildingElement, location=\"Fundering\""}
Palen | {"type": "BBIM_Search", "query": "location=\"Fundering\", IfcPile"}

# IfcPile: fp_c_d300_lb (23)
In: Fundering
Type - PredefinedType: BORED
Type - Pset_Pile_Custom - Shaft: 220; CuttingHeight: -1780; DrivenPileHeight: -18500; TopUncutPile: -1450
Group: Palenplan totaal, types & inhoud; Palen
Name | Length (mm)
fp_c_d300_lb | 29.9999
fp_c_d300_lb.001 | 29.9999
fp_c_d300_lb.002 | 29.9999
fp_c_d300_lb.003
fp_c_d300_lb.004 | 29.9999
fp_c_d300_lb.005 | 29.9999
fp_c_d300_lb.006 | 29.9999
fp_c_d300_lb.007 | 29.9999
fp_c_d300_lb.008 | 29.9999
fp_c_d300_lb.009 | 29.9999
fp_c_d300_lb.010 | 29.9999
fp_c_d300_lb.011 | 29.9999
fp_c_d300_lb.012 | 29.9999
fp_c_d300_lb.013 | 29.9999
fp_c_d300_lb.014 | 29.9999
fp_c_d300_lb.015 | 29.9999
fp_c_d300_lb.016 | 29.9999
fp_c_d300_lb.017 | 29.9999
fp_c_d300_lb.018 | 29.9999
fp_c_d300_lb.019 | 29.9999
fp_c_d300_lb.020 | 29.9999
fp_c_d300_lb.021 | 29.9999
fp_c_d300_lb.022 | 29.9999

# IfcPileType, no part of this type: fp_c_d300_lo
PredefinedType: BORED

# IfcPileType, no part of this type: fp_c_d300_rb
PredefinedType: BORED

# IfcPileType, no part of this type: fp_c_d300_ro
PredefinedType: BORED

# IfcTypeProduct, no part of this type: 5,0
ApplicableOccurrence: IfcAnnotation/TEXT
EPset_Annotation - Classes: header

# IfcTypeProduct, no part of this type: 7,0
ApplicableOccurrence: IfcAnnotation/TEXT
EPset_Annotation - Classes: title

# IfcTypeProduct, no part of this type: SO_kl_ui
ApplicableOccurrence: IfcAnnotation/SYMBOL
EPset_Annotation - Symbol: sondering_kleef_uitgevoerd

# IfcTypeProduct, no part of this type: kol_beid
ApplicableOccurrence: IfcAnnotation/TEXT
EPset_Annotation - Symbol: kol_beid

# IfcTypeProduct, no part of this type: kol_bov
ApplicableOccurrence: IfcAnnotation/TEXT
EPset_Annotation - Symbol: kol_bov

# IfcTypeProduct, no part of this type: kol_ond
ApplicableOccurrence: IfcAnnotation/TEXT
EPset_Annotation - Symbol: kol_ond

# IfcTypeProduct, no part of this type: pn_2_5
ApplicableOccurrence: IfcAnnotation/TEXT
EPset_Annotation - Symbol: pn_2_5; Classes: bold
